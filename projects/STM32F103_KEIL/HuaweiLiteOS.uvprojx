# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_1,STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\link\keil;..\..\example\include;..\..\platform\MM32F103_MINI;..\..\fwlib\inc;..\..\fwlib\startup;..\..\hardware\inc;..\..\NET\protocol\inc;..\..\NET\device\inc;..\..\user;..\..\user\oceansample;..\..\agenttiny;..\..\microcoap
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/mm32f103
    ../../platform/MM32F103_MINI/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/MM32F103_MINI/: startup_stm32f10x_hd.s
    ../../fwlib/startup/: system_stm32f10x.c
  group user
    ../../user/: main.c app.c
    ../../user/oceansample/: ocean_sample.c
  group fwlib
    ../../fwlib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
  group hardware
    ../../hardware/src/: bsp_led.c bsp_usart.c
  group net_device
    ../../NET/device/src/: net_io.c net_device.c
  group protocol
    ../../NET/protocol/src/: fault.c onenet.c
  group agenttiny
    ../../agenttiny/: Agenttiny.c ocean_porting.c umini_extern.c
  group microcoap
    ../../microcoap/: coap.c coap_liteos_port.c endpoints.c
